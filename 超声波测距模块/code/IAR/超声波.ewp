# IAR project 超声波.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\code\ROTAI_WQ\超声波测距模块\code\BSP; E:\code\ROTAI_WQ\超声波测距模块\code\LIB; E:\code\ROTAI_WQ\超声波测距模块\code\LIB\inc; E:\code\ROTAI_WQ\超声波测距模块\code\LIB\src; E:\code\ROTAI_WQ\超声波测距模块\code\USR
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: 超声波.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: clock.c delay.c func.c gpio.c time2.c uart1.c
  group LIB
    ../LIB/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_uart1.c
    ../LIB/: stm8s_conf.h
  group USR
    ../USR/: main.c main.h stm8s_it.c
