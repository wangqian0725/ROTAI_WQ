<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x8D85;&#x58F0;&#x6Ce2;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


